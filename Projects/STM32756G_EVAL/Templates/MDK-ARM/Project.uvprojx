# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL(AXI) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM327x6G_EVAL(AXI)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32756G_EVAL;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Drivers\BSP\Components\mfxstm32l152;..\..\..\..\Drivers\BSP\Components\s5k5cag;..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\Drivers\BSP\Components\ts3510;..\..\..\..\Drivers\BSP\Components\wm8994;..\..\..\..\Utilities\Log;..\..\..\..\Utilities\Fonts;..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Example/MDK-ARM
    ./: startup_stm32f756xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32756G_EVAL
    ../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_io.c stm32756g_eval.c stm32756g_eval_sdram.c stm32756g_eval_nor.c stm32756g_eval_camera.c stm32756g_eval_eeprom.c stm32756g_eval_ts.c stm32756g_eval_audio.c stm32756g_eval_sd.c stm32756g_eval_sram.c stm32756g_eval_lcd.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_iwdg.c stm32f7xx_hal_cryp.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_crc.c stm32f7xx_hal_rtc.c stm32f7xx_hal_can.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hash.c stm32f7xx_hal_i2s.c stm32f7xx_hal_nand.c stm32f7xx_hal_rcc.c stm32f7xx_hal_nor.c stm32f7xx_hal_sd.c stm32f7xx_ll_usb.c stm32f7xx_hal_hcd.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_uart.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_cec.c stm32f7xx_hal_sai.c stm32f7xx_hal_pwr.c stm32f7xx_hal_irda.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_usart.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_smartcard.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_eth.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group New Group
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
target STM327x6G_EVAL(TCM) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: as above
  output: STM327x6G_EVAL(TCM) +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32756G_EVAL;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Drivers\BSP\Components\mfxstm32l152;..\..\..\..\Drivers\BSP\Components\s5k5cag;..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\Drivers\BSP\Components\ts3510;..\..\..\..\Drivers\BSP\Components\wm8994;..\..\..\..\Utilities\Log;..\..\..\..\Utilities\Fonts;..\..\..\..\Utilities\CPU;..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
