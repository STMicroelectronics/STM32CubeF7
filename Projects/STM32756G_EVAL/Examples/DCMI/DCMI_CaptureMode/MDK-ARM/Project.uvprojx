# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL (ARM-ADS)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM327x6G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32756G_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_adc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_sdram.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sram.c stm32f7xx_hal.c stm32f7xx_hal_adc_ex.c
  group Example/User
    ../Src/: main.c stm32f7xx_it.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../../../Drivers/BSP/Components/ov5640/: ov5640.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Example/MDK-ARM
    ./: startup_stm32f756xx.s
  group Drivers/BSP/STM327x6G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_sdram.c stm32756g_eval_io.c stm32756g_eval_sram.c stm32756g_eval_camera.c stm32756g_eval_lcd.c stm32756g_eval.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
