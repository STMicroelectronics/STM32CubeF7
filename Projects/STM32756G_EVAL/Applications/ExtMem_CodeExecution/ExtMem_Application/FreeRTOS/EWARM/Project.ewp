# IAR project Project.ewp, settings and files
configuration XIP_QSPI_InternalSRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F750N8 ST STM32F750N8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x90000000U; STM32F750xx; USE_HAL_DRIVER; USE_STM32756G_EVAL; SYSTEM_FREQ=216
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32756G_EVAL; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: XIP_QSPI_InternalSRAM.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: QSPIflash_InternalSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration XIP_QSPI_ExternalSRAM (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: XIP_QSPI_ExternalSRAM.hex
  ILINK.IlinkIcfFile: QSPIflash_ExtrenalSRAM.icf
configuration XIP_QSPI_ExternalSDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x90000000U; STM32F750xx; USE_HAL_DRIVER; USE_STM32756G_EVAL; SYSTEM_FREQ=200
  OBJCOPY.OOCOutputFile: XIP_QSPI_ExternalSDRAM.hex
  ILINK.IlinkIcfFile: QSPIflash_ExtrenalSDRAM.icf
configuration XIP_NOR_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x60000000U; STM32F750xx; USE_HAL_DRIVER; USE_STM32756G_EVAL; SYSTEM_FREQ=216
  OBJCOPY.OOCOutputFile: XIP_NOR_InternalSRAM.hex
  ILINK.IlinkIcfFile: NORflash_InternalSRAM.icf
configuration XIP_NOR_ExternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: XIP_NOR_ExternalSRAM.hex
  ILINK.IlinkIcfFile: NORflash_ExtrenalSRAM.icf
configuration BootRom_ExternalSRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x68000000U; STM32F750xx; USE_HAL_DRIVER; USE_STM32756G_EVAL; SYSTEM_FREQ=216
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkIcfFile: ExternalSRAM_InternalSRAM.icf
configuration BootROM_ExternalSDRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0xC0000000U; STM32F750xx; USE_HAL_DRIVER; USE_STM32756G_EVAL; SYSTEM_FREQ=200
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkIcfFile: ExternalSDRAM_InternalSRAM.icf
  group Doc
    ../: readme.txt
  group Drivers\CMSIS
    ./: startup_stm32f750xx.s
    ../Src/: system_stm32f7xx.c
  group Drivers\STM32F7xx_HAL_Driver
    ../../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c
  group Middlewares\FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares\FreeRTOS\CMSIS_RTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares\FreeRTOS\portable
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group STM32756G_EVAL
    ../../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c
  group User
    ../Src/: main.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
