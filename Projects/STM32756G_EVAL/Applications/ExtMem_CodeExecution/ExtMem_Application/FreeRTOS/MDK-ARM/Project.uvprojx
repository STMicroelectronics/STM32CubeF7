# Keil uVision project Project.uvprojx, settings and files
target XIP_QSPI_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x10000) IROM2(0x00200000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,STM32F750xx,USE_HAL_DRIVER,USE_STM32756G_EVAL,SYSTEM_FREQ=216
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32756G_EVAL;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x4000000
  memory RVCT5: ROM 0x200000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Doc
    ../: readme.txt
  group Drivers\CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers\STM32F7xx_HAL_Driver
    ../../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr.c
  group Middlewares\FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares\FreeRTOS\CMSIS_RTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares\FreeRTOS\portable
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group STM32756G_EVAL
    ../../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c
  group User
    ../Src/: main.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
target XIP_QSPI_ExternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IROM(0x90000000-0x93FFFFFF) IRAM(0x68000000-0x681FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x4000000
  memory RVCT9: RAM 0x68000000 size 0x200000
target XIP_QSPI_ExternalSDRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: as above
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,STM32F750xx,USE_HAL_DRIVER,USE_STM32756G_EVAL,SYSTEM_FREQ=200
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x4000000
  memory RVCT5: ROM 0x200000 size 0x10000
  memory RVCT9: RAM 0xc0000000 size 0x800000
  memory RVCT10: RAM 0x20000000 size 0x10000
target XIP_NOR_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IROM(0x60000000-0x60FFFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x60000000U,STM32F750xx,USE_HAL_DRIVER,USE_STM32756G_EVAL,SYSTEM_FREQ=216
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x40000
target XIP_NOR_ExternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IROM(0x60000000-0x60FFFFFF) IRAM(0x68000000-0x681FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x1000000
  memory RVCT9: RAM 0x68000000 size 0x200000
target BootRom_ExternalSRAM_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: as above
  output: Project +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x68000000U,STM32F750xx,USE_HAL_DRIVER,USE_STM32756G_EVAL,SYSTEM_FREQ=216
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
target BootROM_ExternalSDRAM_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: as above
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0xC0000000U,STM32F750xx,USE_HAL_DRIVER,USE_STM32756G_EVAL,SYSTEM_FREQ=200
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0xc0000000 size 0x800000
  memory RVCT5: ROM 0x200000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 5.1.1
