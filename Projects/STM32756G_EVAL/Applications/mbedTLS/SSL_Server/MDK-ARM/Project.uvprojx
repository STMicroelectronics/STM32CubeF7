# Keil uVision project Project.uvprojx, settings and files
target STM32F756G_EVAL (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F756G_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32756G_EVAL,STM32F756xx,MBEDTLS_CONFIG_FILE="<mbedtls_config.h>",USE_LCD,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32756G_EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netifapi.c sockets.c netbuf.c api_lib.c api_msg.c tcpip.c err.c netdb.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: pbuf.c tcp.c timeouts.c def.c ip.c sys.c netif.c stats.c init.c udp.c inet_chksum.c memp.c tcp_out.c mem.c dns.c raw.c tcp_in.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c croutine.c list.c tasks.c event_groups.c queue.c
  group Middlewares/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Utilities/Log
    ../../../../../../Utilities/Log/: lcd_log.c
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Drivers/BSP/STM32F756G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_lcd.c stm32756g_eval_sdram.c stm32756g_eval.c stm32756g_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: threading.c xtea.c ctr_drbg.c pk_wrap.c ssl_tls.c md2.c ssl_ticket.c padlock.c gcm.c pkwrite.c entropy_poll.c ecjpake.c memory_buffer_alloc.c ecdsa.c x509_crt.c ssl_cache.c x509write_csr.c error.c pk.c x509write_crt.c asn1parse.c ssl_cookie.c ssl_srv.c x509.c ecp.c oid.c pkparse.c pkcs11.c ecdh.c x509_csr.c rsa.c md5.c md.c des.c cipher_wrap.c ripemd160.c cipher.c sha512.c timing.c arc4.c entropy.c aesni.c base64.c ecp_curves.c version.c camellia.c pkcs12.c sha1.c platform.c hmac_drbg.c ssl_cli.c asn1write.c bignum.c aes.c pem.c pkcs5.c havege.c version_features.c ccm.c cmac.c x509_create.c ssl_ciphersuites.c debug.c blowfish.c x509_crl.c certs.c sha256.c dhm.c md4.c md_wrap.c aria.c platform_util.c hkdf.c rsa_internal.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c ssl_server.c hardware_rng.c ethernetif.c net_sockets.c stm32f7xx_it.c stm32f7xx_hal_timebase_tim.c main.c
    ./: retarget.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
  group Middlewares/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c ip4.c dhcp.c ip4_addr.c igmp.c autoip.c ip4_frag.c etharp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_hash.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sdram.c stm32f7xx_hal_eth.c stm32f7xx_hal_rcc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dma2d.c stm32f7xx_hal.c stm32f7xx_hal_rng.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_tim.c
software components: CMSIS:CORE 4.3.0
