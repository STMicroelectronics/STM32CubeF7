# Keil uVision project Project.uvprojx, settings and files
target STM32F756G_Eval (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F756G_Eval
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,MBEDTLS_CONFIG_FILE="<mbedtls_config.h>",USE_LCD,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32756G_EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netifapi.c err.c api_lib.c sockets.c netbuf.c netdb.c api_msg.c tcpip.c
  group Drivers/BSP/STM32F756G_Eval
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_io.c stm32756g_eval_sdram.c stm32756g_eval_lcd.c stm32756g_eval.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c ip.c tcp.c pbuf.c timeouts.c netif.c mem.c stats.c udp.c sys.c memp.c tcp_out.c init.c inet_chksum.c tcp_in.c raw.c dns.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c list.c timers.c event_groups.c croutine.c tasks.c
  group Middlewares/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Utilities/Log
    ../../../../../../Utilities/Log/: lcd_log.c
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c hardware_rng.c ethernetif.c net_sockets.c ssl_client.c stm32f7xx_hal_timebase_tim.c main.c stm32f7xx_it.c
    ./: retarget.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: md2.c padlock.c dhm.c gcm.c pkwrite.c ssl_ticket.c memory_buffer_alloc.c x509_crt.c ctr_drbg.c pk_wrap.c ssl_tls.c cmac.c asn1parse.c x509_create.c blowfish.c ecdh.c rsa.c md5.c havege.c hmac_drbg.c ecjpake.c ssl_cli.c des.c cipher_wrap.c pem.c pkcs5.c threading.c cipher.c pk.c timing.c ssl_cache.c entropy.c error.c x509write_crt.c camellia.c ssl_cookie.c ssl_srv.c ecp.c oid.c platform.c x509_csr.c pkcs11.c md.c asn1write.c aes.c md_wrap.c x509write_csr.c ripemd160.c sha512.c version_features.c arc4.c aesni.c ecp_curves.c ssl_ciphersuites.c x509.c pkparse.c x509_crl.c certs.c sha256.c entropy_poll.c md4.c bignum.c ecdsa.c xtea.c ccm.c base64.c version.c debug.c sha1.c pkcs12.c aria.c platform_util.c hkdf.c rsa_internal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_eth.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cryp.c stm32f7xx_hal.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rng.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_tim.c stm32f7xx_hal_dsi.c stm32f7xx_hal_pwr.c stm32f7xx_hal_adc.c stm32f7xx_hal_hash.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_adc_ex.c
  group Middlewares/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c etharp.c autoip.c dhcp.c ip4.c ip4_frag.c ip4_addr.c igmp.c
software components: CMSIS:CORE 4.3.0
