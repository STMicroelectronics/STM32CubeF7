# Keil uVision project Project.uvprojx, settings and files
target STM32F746ZG-Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746ZG-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32F7XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP//STM32F7xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32f7xx_it.c stm32f7xx_hal_msp.c main.c
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr.c stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_i2s.c stm32f7xx_hal_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32F746ZG-Nucleo
    ../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
