# Keil uVision project Project.uvprojx, settings and files
target STM32746ZG_Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746ZG_Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,SE_STM32F7XX_NUCLEO_144,USE_USB_FS,HAL_SPI_MODULE_ENABLED,ADAFRUIT_TFT_JOY_SD_ID802
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Drivers/BSP/Adafruit_Shield
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Application/User
    ../Src/: main.c usbd_conf.c stm32f7xx_it.c usbd_desc.c usbd_storage.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc_data.c usbd_msc.c usbd_msc_scsi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/BSP/STM32F7xx_nucleo_144
    ../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_fmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_spi.c stm32f7xx_hal_pcd.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_usb.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr.c
software components: CMSIS:CORE 4.3.0
