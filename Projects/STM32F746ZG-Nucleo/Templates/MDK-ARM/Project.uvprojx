# Keil uVision project Project.uvprojx, settings and files
target STM32F746ZG_Nucleo_ITCM-FLASH (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F746ZG_Nucleo_ITCM-FLASH
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32F7XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32F7xx_Nucleo
    ../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_hash_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_hcd.c stm32f7xx_hal_crc.c stm32f7xx_hal_adc.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_cec.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c stm32f7xx_hal_pcd.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_gpio.c stm32f7xx_hal_nand.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rng.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_lptim.c stm32f7xx_hal_uart.c stm32f7xx_ll_usb.c stm32f7xx_hal.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_sram.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_cryp.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_can.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_irda.c stm32f7xx_hal_nor.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_i2s.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_usart.c stm32f7xx_hal_sai.c stm32f7xx_hal_dcmi.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sd.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_hash.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_sai_ex.c
  group Example/User
    ../Src/: stm32f7xx_hal_msp.c stm32f7xx_it.c main.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
target STM32F746ZG_Nucleo_AXIM-FLASH (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746ZG_Nucleo_AXIM-FLASH
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32F7XX_NUCLEO_144
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.3.0
