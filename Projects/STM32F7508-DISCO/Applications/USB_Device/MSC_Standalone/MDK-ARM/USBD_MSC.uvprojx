# Keil uVision project USBD_MSC.uvprojx, settings and files
target STM32F7508-DISCO_USBD-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x10000) IROM2(0x00200000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G-DISCOVERY_USBD-FS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,SYSTEM_FREQ=216,USE_HAL_DRIVER,STM32F750xx,USE_STM32F7508_DISCO,USE_USB_FS
  c include: ../Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F7508-Discovery;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x1000000
  memory RVCT5: ROM 0x200000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c usbd_conf.c usbd_desc.c usbd_storage.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM327508_DISCOVERY
    ../../../../../../Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
target STM32F7508-DISCO_USBD-HS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: as above
  output: STM32746G-DISCOVERY_USBD-HS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,SYSTEM_FREQ=216,USE_HAL_DRIVER,STM32F750xx,USE_STM32F7508_DISCO,USE_USB_HS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x1000000
  memory RVCT5: ROM 0x200000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 4.3.0
