# Keil uVision project Project.uvprojx, settings and files
target STM32F7508-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IROM(0x90000000-0x90FFFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx,USE_STM32F7508_DISCO,APPLICATION_ADDRESS=0x90000000
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F7508-Discovery;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../Drivers/BSP/Components/ov9655/: ov9655.c
  group Drivers/BSP/STM32F7508-DISCO
    ../../../../../Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery_camera.c stm32f7508_discovery_lcd.c stm32f7508_discovery_sdram.c stm32f7508_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c
software components: CMSIS:CORE 4.3.0
