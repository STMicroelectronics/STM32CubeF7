# IAR project Project.ewp, settings and files
configuration XIP_QSPI_InternalSRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F750N8 ST STM32F750N8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x90000000U; SYSTEM_FREQ=216; USE_HAL_DRIVER; STM32F750xx; USE_STM32F7508_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F7508-Discovery; ..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Drivers\BSP\Components
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XIP_QSPI_InternalSRAM.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: QSPIflash_InternalSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration XIP_QSPI_ExternalSDRAM (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: XIP_QSPI_ExternalSDRAM.hex
  ILINK.IlinkIcfFile: QSPIflash_ExtrenalSDRAM.icf
configuration BootROM_ExternalSDRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0xC0000000U; SYSTEM_FREQ=216; USE_HAL_DRIVER; STM32F750xx; USE_STM32F7508_DISCO
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkIcfFile: ExternalSDRAM_InternalSRAM.icf
  group Example/EWARM
    ./: startup_stm32f750xx.s
  group Example/User
    ../Src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
