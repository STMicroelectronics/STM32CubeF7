# Keil uVision project Project.uvprojx, settings and files
target STM32F7508-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IROM(0x90780000-0x9097FFFF) IRAM(0x20000000-0x2004BFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F7508-Discovery_TouchGFX_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000,ST,USE_HAL_DRIVER,STM32F750xx,USE_STM32F7508_DISCO,USE_BPP=16
  c misc: --diag_suppress 1300
  c include: ../Config;../Core/Inc;../Gui/target;../Gui/gui/include;../Gui/target/include;../Gui/platform/os;../Gui/generated/fonts/include;../Gui/generated/images/include;../Gui/generated/texts/include;../Gui/generated/gui_generated/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F7508-Discovery;../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../Drivers/CMSIS/Include
  asm include: ../Config;../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90780000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x4c000
  scatter file: STM32F7508-Discovery\Exe\STM32F7508-Discovery_TouchGFX_Demo.sct
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/User/TouchGFX/generated/fonts
    ../Gui/generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Bold_otf_12_4bpp.cpp Font_Asap_Bold_otf_15_4bpp.cpp Font_Asap_Bold_otf_18_4bpp.cpp Font_Asap_Bold_otf_46_4bpp.cpp Font_Asap_Regular_11_4bpp.cpp Font_Asap_Regular_12_4bpp.cpp Font_Asap_Regular_15_4bpp.cpp Font_Asap_Regular_18_4bpp.cpp Font_ipaexg_12_4bpp.cpp Font_ipaexg_18_4bpp.cpp Font_NotoSans_Regular_12_4bpp.cpp Font_NotoSans_Regular_18_4bpp.cpp FontGetters.cpp Kerning_Asap_Bold_otf_12_4bpp.cpp Kerning_Asap_Bold_otf_15_4bpp.cpp Kerning_Asap_Bold_otf_18_4bpp.cpp Kerning_Asap_Bold_otf_46_4bpp.cpp Kerning_Asap_Regular_11_4bpp.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_15_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Kerning_ipaexg_12_4bpp.cpp Kerning_ipaexg_18_4bpp.cpp Kerning_NotoSans_Regular_12_4bpp.cpp Kerning_NotoSans_Regular_18_4bpp.cpp Table_Asap_Bold_otf_12_4bpp.cpp Table_Asap_Bold_otf_15_4bpp.cpp Table_Asap_Bold_otf_18_4bpp.cpp Table_Asap_Bold_otf_46_4bpp.cpp Table_Asap_Regular_11_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_15_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp Table_ipaexg_12_4bpp.cpp Table_ipaexg_18_4bpp.cpp Table_NotoSans_Regular_12_4bpp.cpp Table_NotoSans_Regular_18_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../Gui/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../Gui/generated/gui_generated/src/containers/: McuLoadWidgetBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/customcontrols_screen
    ../Gui/generated/gui_generated/src/customcontrols_screen/: CustomControlsViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/easingequation_screen
    ../Gui/generated/gui_generated/src/easingequation_screen/: EasingEquationViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/graph_screen
    ../Gui/generated/gui_generated/src/graph_screen/: GraphViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/mainmenu_screen
    ../Gui/generated/gui_generated/src/mainmenu_screen/: MainMenuViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/productpresenter_screen
    ../Gui/generated/gui_generated/src/productpresenter_screen/: ProductPresenterViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../Gui/generated/images/src/: BitmapDatabase.cpp
  group Application/User/TouchGFX/generated/images/CustomControls
    ../Gui/generated/images/src/CustomControls/: control_center_button.cpp control_center_button_pressed.cpp control_color_wheel.cpp control_menu_arrow_down.cpp control_menu_arrow_down_inactive.cpp control_menu_arrow_down_pressed.cpp control_menu_arrow_up-inactive.cpp control_menu_arrow_up.cpp control_menu_arrow_up_pressed.cpp control_menu_button.cpp control_menu_button_pressed.cpp control_menu_icon_datepicker_large.cpp control_menu_icon_datepicker_small.cpp control_menu_icon_gauge_large.cpp control_menu_icon_gauge_small.cpp control_menu_icon_percentage_large.cpp control_menu_icon_percentage_small.cpp control_menu_icon_three_way_large.cpp control_menu_icon_three_way_small.cpp control_menu_shadow_bottom.cpp control_menu_shadow_top.cpp controls_background.cpp controls_menu_background.cpp controls_three_way_small_circle.cpp controls_wheel_background.cpp datepicker_bottom_shadow_overlay.cpp datepicker_glass_overlay.cpp datepicker_main_background.cpp datepicker_top_shadow_overlay.cpp gauge_background.cpp gauge_needle_pin.cpp small_circle_bin_icon_active.cpp small_circle_bin_icon_inactive.cpp small_circle_folder_icon_active.cpp small_circle_folder_icon_inactive.cpp small_circle_papers_icon_active.cpp small_circle_papers_icon_inactive.cpp
  group Application/User/TouchGFX/generated/images/EasingEquation
    ../Gui/generated/images/src/EasingEquation/: easing_background.cpp easing_bottom_menu.cpp easing_bottom_menu_active.cpp easing_bottom_menu_selected.cpp easing_dot.cpp easing_menu_button.cpp easing_menu_button_pressed.cpp easing_side_menu_button.cpp easing_side_menu_button_active.cpp easing_side_menu_button_selected.cpp graphDot.cpp
  group Application/User/TouchGFX/generated/images/Graph
    ../Gui/generated/images/src/Graph/: blue_area_button_active.cpp blue_area_button_inactive.cpp blue_dots_button_active.cpp blue_dots_button_inactive.cpp blue_line_button_active.cpp blue_line_button_inactive.cpp graph_background_bottom.cpp graph_menu_button.cpp graph_menu_button_pressed.cpp graph_toggle_button_active.cpp graph_toggle_button_inactive.cpp graph_top_menu_activate_button.cpp graph_top_menu_line.cpp green_area_button_active.cpp green_area_button_inactive.cpp green_dots_button_active.cpp green_dots_button_inactive.cpp green_line_button_active.cpp green_line_button_inactive.cpp half_circle_toggle_button_active.cpp half_circle_toggle_button_inactive.cpp new_graph.cpp new_graph_pressed.cpp new_pie_chart.cpp new_pie_chart_pressed.cpp pie_chart_legend_blue.cpp pie_chart_legend_blue_active.cpp pie_chart_legend_green.cpp pie_chart_legend_green_active.cpp pie_chart_legend_orange.cpp pie_chart_legend_orange_active.cpp pie_chart_legend_purple.cpp pie_chart_legend_purple_active.cpp pie_chart_legend_red.cpp pie_chart_legend_red_active.cpp pie_chart_legend_yellow.cpp pie_chart_legend_yellow_active.cpp pie_toggle_button_active.cpp pie_toggle_button_inactive.cpp
  group Application/User/TouchGFX/generated/images/MainMenu
    ../Gui/generated/images/src/MainMenu/: demo_button_01.cpp demo_button_01_pressed.cpp demo_button_02_03.cpp demo_button_02_03_pressed.cpp demo_button_04.cpp demo_button_04_pressed.cpp demo_button_05_06.cpp demo_button_05_06_pressed.cpp menu_demo_screen_02.cpp menu_demo_screen_03.cpp menu_demo_screen_04.cpp menu_demo_screen_05.cpp menu_stage_stretch_left_side.cpp menu_stage_stretch_right_side.cpp screen_swipe_dots_active.cpp screen_swipe_dots_inactive.cpp
  group Application/User/TouchGFX/generated/images/ProductPresenter
    ../Gui/generated/images/src/ProductPresenter/: flag_dnk_active.cpp flag_dnk_inactive.cpp flag_gbr_active.cpp flag_gbr_inactive.cpp flag_jpn_active.cpp flag_jpn_inactive.cpp flag_nld_active.cpp flag_nld_inactive.cpp flag_ukr_active.cpp flag_ukr_inactive.cpp poster_image_00.cpp poster_image_01.cpp poster_image_02.cpp product_presenter_menu_button.cpp product_presenter_menu_button_pressed.cpp product_presenter_nav_bar.cpp product_presenter_next.cpp product_presenter_next_pressed.cpp
  group Application/User/TouchGFX/generated/texts
    ../Gui/generated/texts/src/: LanguageDnk.cpp LanguageGbr.cpp LanguageJpn.cpp LanguageNld.cpp LanguageUkr.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../Gui/gui/src/common/: DotIndicator.cpp FrontendApplication.cpp SwipeContainer.cpp
  group Application/User/TouchGFX/gui/containers
    ../Gui/gui/src/containers/: mcuLoadWidget.cpp
  group Application/User/TouchGFX/gui/customcontrols_screen
    ../Gui/gui/src/customcontrols_screen/: CircularProgress.cpp CustomControlsPresenter.cpp CustomControlsView.cpp DatePicker.cpp Gauge.cpp ThreeWayProgressBar.cpp ThreeWayProgressBarCircle.cpp VerticalSlideMenu.cpp WheelSelector.cpp WheelSelectorExtra.cpp
  group Application/User/TouchGFX/gui/easingequation_screen
    ../Gui/gui/src/easingequation_screen/: EasingEquationButton.cpp EasingEquationGraph.cpp EasingEquationInOutSelectorGroup.cpp EasingEquationPresenter.cpp EasingEquationSelector.cpp EasingEquationView.cpp
  group Application/User/TouchGFX/gui/graph_screen
    ../Gui/gui/src/graph_screen/: GraphPresenter.cpp GraphView.cpp LegendEntry.cpp PieChart.cpp
  group Application/User/TouchGFX/gui/graph_screen/graph_widget
    ../Gui/gui/src/graph_screen/graph_widget/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp PainterVerticalAlpha.cpp
  group Application/User/TouchGFX/gui/mainmenu_screen
    ../Gui/gui/src/mainmenu_screen/: MainMenuPresenter.cpp MainMenuView.cpp
  group Application/User/TouchGFX/gui/model
    ../Gui/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/productpresenter_screen
    ../Gui/gui/src/productpresenter_screen/: CollapsibleMenu.cpp ProductPresenterPresenter.cpp ProductPresenterView.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery_qspi.c stm32f7508_discovery_sd.c stm32f7508_discovery_sdram.c stm32f7508_discovery_ts.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c stm32f7xx_ll_sdmmc.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middlewares/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Middlewares/TouchGFX/Target
    ../Gui/target/: BoardConfiguration.cpp GPIO.cpp STM32F746GTouchController.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7Instrumentation.cpp
software components: CMSIS:CORE 4.3.0
