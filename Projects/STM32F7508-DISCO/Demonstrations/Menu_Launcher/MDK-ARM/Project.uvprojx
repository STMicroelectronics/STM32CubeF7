# Keil uVision project Project.uvprojx, settings and files
target STM32F7508-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IROM(0x08000000-0x800FFFF) IRAM(0x20000000-0x2004FFFF) IRAM2(0x00000000-0x3FFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Utilities;../../../../../Utilities/Fonts;../../../../../Drivers/BSP/Components;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Drivers/BSP/STM32F7508-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x0 size 0x4000
  scatter file: STM32F7508-DISCO\Exe\Project.sct
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Application/User
    ../Src/: fmc.c main.c memory_msp.c menu_selector.c qspi.c sdcard.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_nor.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
