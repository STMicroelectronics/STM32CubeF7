# IAR project Project.ewp, settings and files
configuration STM32F7508-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F750N8 ST STM32F750N8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F750xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Drivers\BSP\STM32F7508-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F7508-DISCO_MenuLauncher_V1.0.0.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f750xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f750xx.s
  group Application/User
    ../Src/: fmc.c main.c memory_msp.c menu_selector.c qspi.c sdcard.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_nor.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
