# Keil uVision project Project.uvprojx, settings and files
target XIP_QSPI_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F730I8Kx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x10000) IROM2(0x00200000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F730xx,USE_STM32F7308_DISCO,TS_MULTI_TOUCH_SUPPORTED,APPLICATION_ADDRESS=0x90000000
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F7308-Discovery;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Log;../../../../../Utilities/Fonts;../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x4000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32F7308_DISCOVERY
    ../../../../../Drivers/BSP/STM32F7308-Discovery/: stm32f7308_discovery.c stm32f7308_discovery_audio.c stm32f7308_discovery_lcd.c stm32f7308_discovery_psram.c stm32f7308_discovery_qspi.c stm32f7308_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c
  group Example/User
    ../Src/: audio.c audio_record_loopback.c lcd.c log.c main.c psram.c stm32f7xx_it.c touchscreen.c ts_calibration.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Example/MDK-ARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f730xx.s
software components: CMSIS:CORE 4.3.0
