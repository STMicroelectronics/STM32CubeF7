# IAR project Project.ewp, settings and files
configuration XIP_QSPI_InternalSRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F730I8 ST STM32F730I8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F730xx; USE_STM32F7308_DISCO; TS_MULTI_TOUCH_SUPPORTED; APPLICATION_ADDRESS=0x90000000
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32F7308-Discovery; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XIP_QSPI_InternalSRAM.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: QSPIflash_InternalSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32F7308_DISCOVERY
    ../../../../../Drivers/BSP/STM32F7308-Discovery/: stm32f7308_discovery.c stm32f7308_discovery_audio.c stm32f7308_discovery_lcd.c stm32f7308_discovery_psram.c stm32f7308_discovery_qspi.c stm32f7308_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c
  group Example/EWARM
    ./: startup_stm32f730xx.s
  group Example/User
    ../Src/: audio.c audio_record_loopback.c lcd.c log.c main.c psram.c stm32f7xx_it.c touchscreen.c ts_calibration.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
