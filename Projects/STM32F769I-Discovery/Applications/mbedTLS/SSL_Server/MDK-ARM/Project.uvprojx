# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,MBEDTLS_CONFIG_FILE="<mbedtls_config.h>",USE_LCD,_SYSTEM_BUILD
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_dsi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c stm32f7xx_hal_eth.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rng.c stm32f7xx_hal_hash.c stm32f7xx_hal_dma.c
  group Utilities/Log
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c timers.c queue.c croutine.c tasks.c list.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: ethernetif.c ssl_server.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c stm32f7xx_hal_msp.c hardware_rng.c net_sockets.c main.c
    ./: retarget.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: asn1write.c ecp.c sha1.c md5.c platform.c debug.c entropy.c md_wrap.c ssl_cli.c hmac_drbg.c havege.c gcm.c des.c ccm.c pk_wrap.c md4.c pkparse.c error.c base64.c pem.c cipher.c x509.c oid.c x509write_crt.c x509_create.c pkwrite.c x509_crt.c dhm.c version.c ssl_ticket.c ssl_cookie.c padlock.c ssl_cache.c blowfish.c camellia.c pkcs5.c asn1parse.c arc4.c aes.c ecdsa.c timing.c aesni.c pkcs11.c ecp_curves.c entropy_poll.c sha256.c ssl_srv.c ecdh.c bignum.c cmac.c threading.c md.c pkcs12.c x509_csr.c x509_crl.c ctr_drbg.c version_features.c ecjpake.c ripemd160.c ssl_ciphersuites.c xtea.c certs.c memory_buffer_alloc.c ssl_tls.c pk.c rsa.c cipher_wrap.c md2.c sha512.c x509write_csr.c aria.c platform_util.c hkdf.c rsa_internal.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/BSP/STM32F769I_Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_sdram.c stm32f769i_discovery_lcd.c
  group Middlewares/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c icmp.c dhcp.c igmp.c etharp.c autoip.c ip4_frag.c
  group Middlewares/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: raw.c inet_chksum.c tcp.c def.c netif.c stats.c udp.c timeouts.c dns.c tcp_out.c memp.c mem.c ip.c pbuf.c sys.c tcp_in.c init.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: tcpip.c netbuf.c netdb.c sockets.c api_msg.c netifapi.c api_lib.c err.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
software components: CMSIS:CORE 4.3.0
