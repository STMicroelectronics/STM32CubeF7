# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_DISCOVERY (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.2
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO
  c misc: --C99
  c include: ../Inc;../Src;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c dhcp.c autoip.c icmp.c etharp.c ip4_addr.c ip4_frag.c ip4.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dsi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_i2c.c stm32f7xx_hal.c stm32f7xx_hal_rcc_ex.c
  group Application/User
    ../Src/: stm32f7xx_it.c app_ethernet.c main.c httpserver-netconn.c stm32f7xx_hal_timebase_tim.c ethernetif.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: tcp.c timeouts.c tcp_in.c stats.c ip.c raw.c mem.c netif.c sys.c init.c tcp_out.c dns.c memp.c def.c udp.c inet_chksum.c pbuf.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netbuf.c netdb.c sockets.c api_lib.c err.c tcpip.c netifapi.c
  group Drivers/BSP/STM32F769I_Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sdram.c
  group Middlewares/LwIP/apps/http
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/http/: fs.c httpd.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c timers.c croutine.c
software components: CMSIS:CORE 4.3.0
