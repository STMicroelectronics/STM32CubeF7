# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_HS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2007FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F769I_Discovery_HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,USE_USB_HS
  c misc: --C99
  c include: ../Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_uart.c stm32f7xx_hal.c stm32f7xx_hal_usart.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_sd.c stm32f7xx_ll_usb.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_flash.c stm32f7xx_ll_sdmmc.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c usbd_desc.c usbd_conf.c usbd_storage.c main.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_scsi.c usbd_msc.c usbd_msc_bot.c usbd_msc_data.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery_sd.c stm32f769i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
