# Keil uVision project Project.uvprojx, settings and files
target STM32769I-Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32769I-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,TS_MULTI_TOUCH_SUPPORTED
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Example/User
    ../Src/: qspi.c stm32f7xx_it.c sd.c audio_loopback.c touchscreen.c audio_play.c log.c sdram.c lcd.c main.c
  group Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery_qspi.c stm32f769i_discovery_audio.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sd.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_wwdg.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_nor.c stm32f7xx_hal_adc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_pwr.c stm32f7xx_hal_lptim.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_dma.c stm32f7xx_hal_hash.c stm32f7xx_ll_fmc.c stm32f7xx_hal_flash.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_eth.c stm32f7xx_hal_hcd.c stm32f7xx_hal.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_qspi.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sai.c stm32f7xx_ll_usb.c stm32f7xx_hal_tim.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_dac.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_nand.c stm32f7xx_hal_pcd.c stm32f7xx_hal_uart.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dsi.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_irda.c stm32f7xx_hal_crc.c stm32f7xx_hal_mdios.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_cryp.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_rng.c stm32f7xx_hal_i2s.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_can.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_smartcard.c
  group Example/MDK-ARM
    ./: startup_stm32f769xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
software components: CMSIS:CORE 4.3.0
