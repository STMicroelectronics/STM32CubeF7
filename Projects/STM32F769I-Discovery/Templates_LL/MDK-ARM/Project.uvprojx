# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_AXIM_FLASH (6070000::V6.7::.\ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32F769I_Discovery_AXIM_FLASH
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F769xx
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Example/MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/STM32F7xx_LL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_adc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_pwr.c stm32f7xx_ll_usart.c stm32f7xx_ll_rng.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_utils.c stm32f7xx_ll_rcc.c stm32f7xx_ll_crc.c stm32f7xx_ll_i2c.c stm32f7xx_ll_exti.c stm32f7xx_ll_dma.c
  group Example/User
    ../Src/: main.c stm32f7xx_it.c
target STM32F769I_Discovery_ITCM_FLASH (6070000::V6.7::.\ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_Discovery_ITCM_FLASH
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F769xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
software components: CMSIS:CORE 5.3.0
