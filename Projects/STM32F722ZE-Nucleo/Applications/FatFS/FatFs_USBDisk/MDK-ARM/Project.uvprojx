# Keil uVision project Project.uvprojx, settings and files
target STM32F722ZE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F722ZETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F722ZE_Nucleo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F722xx,USE_HAL_DRIVER,USE_STM32F7XX_NUCLEO_144,USE_USB_FS
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP//STM32F7xx_Nucleo_144;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/Adafruit_Shield;../../../../../../Drivers/BSP/Components/st7735;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_core.c usbh_ctlreq.c usbh_ioreq.c
  group Middlewares/FatFs/Option
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Application/MDK-ARM
    ./: startup_stm32f722xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c usbh_conf.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_ll_fmc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_usb.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Drivers/BSP/STM32F722ZE_Nucleo
    ../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio.c
software components: CMSIS:CORE 5.0.1
