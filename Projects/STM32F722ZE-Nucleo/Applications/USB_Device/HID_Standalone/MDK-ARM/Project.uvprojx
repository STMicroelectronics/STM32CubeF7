# Keil uVision project Project.uvprojx, settings and files
target STM32F722ZE_Nucleo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F722ZETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.1
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32F722ZE_Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F722xx,USE_USB_FS,USE_STM32F7XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP//STM32F7xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/MDK-ARM
    ./: startup_stm32f722xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c usbd_conf.c main.c usbd_desc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32F7xx_nucleo_144
    ../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_sdram.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_pcd.c stm32f7xx_ll_fmc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_sram.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_rcc.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
