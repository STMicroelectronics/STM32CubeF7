# Keil uVision project Project.uvprojx, settings and files
target STM32F767ZI_Nucleo_AXIM_FLASH (6070000::V6.7::.\ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2007FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F767ZI_Nucleo_AXIM_FLASH
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx,USE_STM32F7XX_NUCLEO_144
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F7xx_Nucleo_144;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/Fonts;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F767ZI-Nucleo
    ../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Drivers/BSP/AdafruitShield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Example/User
    ../Src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal.c stm32f7xx_hal_lptim.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_hash.c stm32f7xx_ll_usb.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_usart.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_nand.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_adc.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_cec.c stm32f7xx_hal_pwr.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_rtc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_sai.c stm32f7xx_hal_spi.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2s.c stm32f7xx_hal_dac.c stm32f7xx_hal_crc.c stm32f7xx_hal_pcd.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_eth.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_irda.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_flash.c stm32f7xx_hal_sram.c stm32f7xx_hal_qspi.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_mdios.c stm32f7xx_hal_i2c.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sd.c
  group Example/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
target STM32F767ZI_Nucleo_ITCM_FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: as above
  output: STM32F767ZI_Nucleo_ITCM_FLASH
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx,USE_STM32F7XX_NUCLEO_144
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.3.0
