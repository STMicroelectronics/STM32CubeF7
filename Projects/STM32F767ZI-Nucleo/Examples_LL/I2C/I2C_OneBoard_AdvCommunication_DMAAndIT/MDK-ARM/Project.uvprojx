# Keil uVision project Project.uvprojx, settings and files
target STM32F767ZI-Nucleo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F767ZI-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F767xx,USE_STM32F7XX_NUCLEO,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U,__DBG_ITM
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f767xx.s
  group Example/User
    ../Src/: main.c stm32f7xx_it.c
    ./: Retarget.c Serial.c
  group Drivers/STM32F7xx_LL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
