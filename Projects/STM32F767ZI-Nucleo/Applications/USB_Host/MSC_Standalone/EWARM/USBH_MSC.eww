<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_MSC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBH_MSC</project>
        <configuration>STM32F767ZI_Nucleo_USBH-FS</configuration>
      </member>
      <member>
        <project>USBH_MSC</project>
        <configuration>STM32F767ZI_Nucleo_USBH-HS</configuration>
      </member>
      <member>
        <project>USBH_MSC</project>
        <configuration>STM32F767ZI_Nucleo_USBH-HS-IN-FS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


