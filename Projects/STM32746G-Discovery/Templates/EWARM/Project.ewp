# IAR project Project.ewp, settings and files
configuration STM32746G_Discovery_ITCM-FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32746G-Discovery; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Drivers\BSP\Components\ft5336; ..\..\..\..\Drivers\BSP\Components\ov9655; ..\..\..\..\Drivers\BSP\Components\rk043fn48h; ..\..\..\..\Drivers\BSP\Components\n25q128a; ..\..\..\..\Drivers\BSP\Components\wm8994; ..\..\..\..\Utilities\Log; ..\..\..\..\Utilities\Fonts; ..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32746G_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f746xx_ITCM_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32746G_Discovery_AXIM-FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../Drivers/BSP/Components/ov9655/: ov9655.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32746G_Discovery
    ../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32f746xx.s
  group Example/User
    ../Src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
