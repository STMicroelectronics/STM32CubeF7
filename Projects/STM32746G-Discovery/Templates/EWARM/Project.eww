<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD - ALL</name>
      <member>
        <project>Project</project>
        <configuration>STM32746G_Discovery</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>STM32746G_Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


