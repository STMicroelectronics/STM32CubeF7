# Keil uVision project Project.uvprojx, settings and files
target STM32746G-DISCOVERY_USBH (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32746G-DISCOVERY_USBH-FS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_sdram.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_i2c.c stm32f7xx_ll_usb.c stm32f7xx_hal_hcd.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c
  group Middlewares/FatFS/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Application/User/MSC
    ../Src/: msc_menu.c explorer.c file_operations.c
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c usbh_hid.c
  group Middlewares/FatFS/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User/HID
    ../Src/: hid_menu.c keyboard.c mouse.c
  group Middlewares/FatFS/Drivers
    ../Src/: usbh_diskio_dma.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c
  group Drivers/BSP/STM32746G_DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_sdram.c stm32746g_discovery.c stm32746g_discovery_lcd.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: dual_menu.c usbh_conf.c main.c stm32f7xx_it.c
software components: CMSIS:CORE 4.3.0
