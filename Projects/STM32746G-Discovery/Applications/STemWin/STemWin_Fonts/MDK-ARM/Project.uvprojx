# Keil uVision project Project.uvprojx, settings and files
target STM32746G_DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32756G_DISCOVERY
  c misc: --C99
  c include: ../Core/Inc;../STemWin/App/generated/fonts;../STemWin/App/generated/images;../STemWin/Target;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Utilities;../../../../../../Utilities/Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/BSP/component
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
  group Doc
    ../: readme.txt
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_it.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_i2c_ex.c
  group Application/User/STemWin
    ../STemWin/App/: font_app.c
  group Middlewares/STemWin/Target
    ../STemWin/Target/: LCDConf.c GUIConf.c
  group Middlewares/STemWin/Config
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32746G_DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_ts.c stm32746g_discovery_sdram.c stm32746g_discovery.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_wc16_ARGB.a
software components: CMSIS:CORE 4.3.0
