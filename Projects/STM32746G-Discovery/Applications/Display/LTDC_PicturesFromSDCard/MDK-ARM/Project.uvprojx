# Keil uVision project Project.uvprojx, settings and files
target STM32746G-DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Utilities;../../../../../../Utilities/fonts;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/BSP/Components
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/BSP/STM32746G-DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_sdram.c stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Application/User
    ../Src/: stm32f7xx_it.c fatfs_storage.c main.c
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Option
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
