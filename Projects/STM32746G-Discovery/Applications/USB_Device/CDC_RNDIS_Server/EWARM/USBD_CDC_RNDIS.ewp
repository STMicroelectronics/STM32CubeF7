# IAR project USBD_CDC_RNDIS.ewp, settings and files
configuration STM32746G-DISCOVERY_USBD-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO; USE_USB_FS
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_RNDIS\Inc; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32746G-Discovery; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\apps\http; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\Core\Inc; ..\LwIP\App; ..\LwIP\Target; ..\USB_Device\App; ..\USB_Device\Target
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32746G-DISCOVERY_USBD-FS.hex
  ILINK.IlinkOutputFile: USBD_CDC_RNDIS.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32746G-DISCOVERY_USBD-HS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO; USE_USB_HS
  OBJCOPY.OOCOutputFile: STM32746G-DISCOVERY_USBD-HS.hex
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group Application/User/LwIP/App
    ../LwIP/App/: httpd_cgi_ssi.c
  group Application/User/LwIP/Target
    ../LwIP/Target/: ethernetif.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_cdc_rndis_if.c usbd_desc.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32746G_DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_usb.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/apps/http
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/http/: fs.c httpd.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Middlewares/STM32_USBD_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_RNDIS/Src/: usbd_cdc_rndis.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
