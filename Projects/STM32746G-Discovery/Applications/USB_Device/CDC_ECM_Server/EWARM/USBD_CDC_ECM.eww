<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USBD_CDC_ECM.ewp</path>
    </project>
    <batchBuild />
</workspace>
