# IAR project USBD_AUDIO.ewp, settings and files
configuration STM32746G-DISCOVERY_USBD-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO; USE_USB_FS; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32746G-Discovery; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32746G-DISCOVERY_USBD-FS.hex
  ILINK.IlinkOutputFile: STM32746G-DISCOVERY_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c usbd_audio_if.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32746G-DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2s.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_usb.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_IAR_wc32.a
  group Middlewares/STM32_USBD_Library/Class/AUDIO
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
