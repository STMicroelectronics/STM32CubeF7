<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build all</name>
      <member>
        <project>Project</project>
        <configuration>FPU-Off</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>FPU-On</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


