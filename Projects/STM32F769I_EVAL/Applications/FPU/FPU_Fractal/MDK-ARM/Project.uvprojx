# Keil uVision project Project.uvprojx, settings and files
target FPU-On (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: FPU-On
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Drivers/BSP/STM32F769I_EVAL
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval_ts.c stm32f769i_eval_lcd.c stm32f769i_eval.c stm32f769i_eval_io.c stm32f769i_eval_sdram.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/stm32f7xx_hal_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr.c stm32f7xx_hal_cortex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dsi.c stm32f7xx_ll_fmc.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: main.c button.c stm32f7xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Doc
    ../: readme.txt
target FPU-Off (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: as above
  output: FPU-Off
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
software components: CMSIS:CORE 4.3.0
