# IAR project USBH_CDC.ewp, settings and files
configuration STM32F769I-EVAL_USBH-HS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_EVAL; USE_USB_HS; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F769I_EVAL; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\..\Utilities\Log
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F769I-EVAL_USBH-HS.hex
  ILINK.IlinkOutputFile: STM32F769I-EVAL_USBH-HS.out
  ILINK.IlinkIcfFile: stm32F769xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F769I_EVAL_USBH-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_EVAL; USE_USB_FS; USE_IOEXPANDER
  OBJCOPY.OOCOutputFile: STM32F769I-EVAL_USBH-FS.hex
  ILINK.IlinkOutputFile: STM32F769I-EVAL_USBH-FS.out
configuration STM32F769I_EVAL_USBH-HS-IN-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_EVAL; USE_USB_HS; USE_USB_HS_IN_FS; USE_IOEXPANDER
  OBJCOPY.OOCOutputFile: STM32F769I-EVAL_USBH-HS-IN-FS.hex
  ILINK.IlinkOutputFile: STM32F769I-EVAL_USBH-HS-IN-FS.out
  group Application/EWARM
    ./: startup_stm32f769xx.s
  group Application/User
    ../Src/: cdc_configuration.c cdc_receive.c cdc_send.c explorer.c main.c menu.c stm32f7xx_it.c usbh_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/BSP/STM32F769I_EVAL
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval.c stm32f769i_eval_io.c stm32f769i_eval_lcd.c stm32f769i_eval_sd.c stm32f769i_eval_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/FatFS/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFS/Drivers
    ../Src/: sd_diskio.c
  group Middlewares/STM32_USBH_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
