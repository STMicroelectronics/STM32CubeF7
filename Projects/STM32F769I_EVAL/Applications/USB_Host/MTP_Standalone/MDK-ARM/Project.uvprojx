# Keil uVision project Project.uvprojx, settings and files
target STM32F769I-EVAL_USBH-FS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2007FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F769I-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_EVAL,USE_USB_FS,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Inc;../../../../../../Drivers/BSP/STM32F769I_EVAL;../../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Application/User
    ../Src/: stm32f7xx_it.c mtp.c usbh_conf.c menu.c audio.c main.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/BSP/STM32F769I_EVAL
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval_sd.c stm32f769i_eval_lcd.c stm32f769i_eval_io.c stm32f769i_eval_audio.c stm32f769i_eval.c stm32f769i_eval_sdram.c
  group Middlewares/STM32_USBH_Library/Class/MTP
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Src/: usbh_mtp.c usbh_mtp_ptp.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c usbh_core.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_adc.c stm32f7xx_hal_sd.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2s.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_uart.c stm32f7xx_hal_flash.c stm32f7xx_hal_sai.c stm32f7xx_ll_usb.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dsi.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_hcd.c
  group Doc
    ../: readme.txt
target STM32F769I_EVAL_USBH-HS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: as above
  output: STM32F769I_EVAL_USBH-HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_EVAL,USE_USB_HS,USE_IOEXPANDER
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
target STM32F769I_EVAL_USBH-HS-IN-FS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: as above
  output: STM32F769I_EVAL_USBH-HS-IN-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_EVAL,USE_USB_HS,USE_USB_HS_IN_FS,USE_IOEXPANDER
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
