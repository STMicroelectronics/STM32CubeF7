# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2007FFFF) IRAM(0x00000000-0x3FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_EVAL,USE_IOEXPANDER
  c include: ../Core/Inc;../STemWin/Target;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I_EVAL;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Utilities;../../../../../../Utilities/Fonts;../STemWin/App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/User/Core
    ../Core/Src/: rtc.c main.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_wc16.a
  group Drivers/BSP/STM32769I_EVAL
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval.c stm32f769i_eval_sdram.c stm32f769i_eval_ts.c stm32f769i_eval_io.c
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Application/User/STemWin
    ../STemWin/App/: GUIDEMO_TransparentDialog.c GUIDEMO_VScreen.c GUIDEMO_Resource.c GUIDEMO_RadialMenu.c GUIDEMO_Listview.c GUIDEMO_Treeview.c GUIDEMO.c GUIDEMO_Cursor.c GUIDEMO_ColorBar.c GUIDEMO_Bitmap.c GUIDEMO_Conf.c GUIDEMO_Graph.c GUIDEMO_Start.c GUIDEMO_Automotive.c GUIDEMO_Intro.c GUIDEMO_IconView.c GUIDEMO_Speed.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/STemWin/Target
    ../STemWin/Target/: GUIConf_stm32f769i_eval.c LCDConf_stm32f769i_eval.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc.c stm32f7xx_hal_uart.c stm32f7xx_hal_dsi.c stm32f7xx_hal_i2c.c stm32f7xx_hal.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_adc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rtc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_gpio.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
software components: CMSIS:CORE 4.3.0
