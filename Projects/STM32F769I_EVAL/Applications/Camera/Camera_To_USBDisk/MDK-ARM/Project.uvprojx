# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_IOEXPANDER,USE_STM32F769I_EVAL,USE_USB_HS
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I_EVAL;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Utilities;../../../../../../Utilities/fonts;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Middlewares/FatFs/Option
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c usbh_core.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: main.c usbh_conf.c stm32f7xx_it.c
  group Drivers/BSP/STM32F769I_EVAL
    ../../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval_camera.c stm32f769i_eval.c stm32f769i_eval_io.c stm32f769i_eval_lcd.c stm32f769i_eval_sdram.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc.c stm32f7xx_hal_uart.c stm32f7xx_hal_dsi.c stm32f7xx_hal_i2c.c stm32f7xx_hal.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_ll_fmc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_gpio.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
software components: CMSIS:CORE 4.3.0
