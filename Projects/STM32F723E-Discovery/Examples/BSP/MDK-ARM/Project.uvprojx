# Keil uVision project Project.uvprojx, settings and files
target STM32F723E-Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F723E-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,TS_MULTI_TOUCH_SUPPORTED
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F723E-Discovery;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Log;../../../../../Utilities/Fonts;../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sram.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_i2c.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_dma_ex.c
  group Drivers/BSP/STM32F723E_DISCOVERY
    ../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery_ts.c stm32f723e_discovery_audio.c stm32f723e_discovery_psram.c stm32f723e_discovery_qspi.c stm32f723e_discovery_lcd.c stm32f723e_discovery.c
  group Example/User
    ../Src/: log.c main.c stm32f7xx_it.c audio_record_loopback.c ts_calibration.c lcd.c psram.c audio.c touchscreen.c qspi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Example/MDK-ARM
    ./: startup_stm32f723xx.s
software components: CMSIS:CORE 4.3.0
