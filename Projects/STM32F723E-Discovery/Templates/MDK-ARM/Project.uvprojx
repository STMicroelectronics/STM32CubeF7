# Keil uVision project Project.uvprojx, settings and files
target STM32F723E_DISCOVERY_AXIM-FLASH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32F723E_DISCOVERY_AXIM-FLASH
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F723E-Discovery;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/Fonts;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Example/MDK-ARM
    ./: startup_stm32f723xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F723E_DISCOVERY
    ../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery_ts.c stm32f723e_discovery_qspi.c stm32f723e_discovery_audio.c stm32f723e_discovery_psram.c stm32f723e_discovery_lcd.c stm32f723e_discovery.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_lptim.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_irda.c stm32f7xx_hal_rtc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_cec.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_nor.c stm32f7xx_hal_adc.c stm32f7xx_hal_tim.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_i2s.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_spi.c stm32f7xx_hal_nand.c stm32f7xx_hal_pcd.c stm32f7xx_hal_flash.c stm32f7xx_hal_hash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sd.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rcc.c stm32f7xx_hal_crc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_exti.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pcd_ex.c
  group Example/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
target STM32F723E_DISCOVERY_ITCM-FLAH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: as above
  output: STM32F723E_DISCOVERY_ITCM-FLAH
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 4.3.0
