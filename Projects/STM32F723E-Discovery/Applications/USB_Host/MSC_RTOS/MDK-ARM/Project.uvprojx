# Keil uVision project Project.uvprojx, settings and files
target STM32F723E_DISCOVERY_USBH-FS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F723E_DISCOVERY_USBH-FS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,USE_USB_FS
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Drivers/BSP/STM32F723E-Discovery;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Utilities/Log
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/MDK-ARM
    ./: startup_stm32f723xx.s
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c croutine.c queue.c tasks.c timers.c
  group Middlewares/FatFS/Options
    ../../../../../../Middlewares/Third_Party/FatFS/src/option/: syscall.c unicode.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_pipes.c usbh_core.c usbh_ioreq.c
  group Middlewares/FatFS/Drivers
    ../Src/: usbh_diskio_dma.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/User
    ../Src/: file_operations.c usbh_conf.c stm32f7xx_hal_timebase_tim.c menu.c explorer.c main.c ts_calibration.c stm32f7xx_it.c
  group Middlewares/FatFS/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c
    ../../../../../../Middlewares/Third_Party/FatFS/src/: ff.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_usb.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sram.c
  group Drivers/BSP/STM32F723E-Discovery
    ../../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery_lcd.c stm32f723e_discovery.c stm32f723e_discovery_ts.c
target STM32F723E_DISCOVERY_USBH-HS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: as above
  output: STM32F723E_DISCOVERY_USBH-HS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,USE_USB_HS
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 5.0.1
