<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_DynamicSwitch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBH_DynamicSwitch</project>
        <configuration>STM32F723IE-DISCOVERY_USBH-FS</configuration>
      </member>
      <member>
        <project>USBH_DynamicSwitch</project>
        <configuration>STM32F723IE-DISCOVERY_USBH-HS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


