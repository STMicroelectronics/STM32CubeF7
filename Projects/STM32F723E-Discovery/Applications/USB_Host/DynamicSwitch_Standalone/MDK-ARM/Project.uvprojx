# Keil uVision project Project.uvprojx, settings and files
target STM32F723E-DISCOVERY_USBH-FS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F723E-DISCOVERY_USBH-FS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,USE_USB_FS
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/BSP/STM32F723E-Discovery;../../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/User/MSC
    ../Src/: file_operations.c msc_menu.c msc_explorer.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c stm32f7xx_hal_sram.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sdram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sd.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal.c stm32f7xx_hal_dma_ex.c
  group Middlewares/FatFS/Drivers
    ../Src/: usbh_diskio_dma.c
  group Drivers/BSP/STM32F723E_DISCOVERY
    ../../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery_lcd.c stm32f723e_discovery_ts.c stm32f723e_discovery.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
  group Application/MDK-ARM
    ./: startup_stm32f723xx.s
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_parser.c usbh_hid_keybd.c usbh_hid.c usbh_hid_mouse.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ioreq.c usbh_ctlreq.c usbh_pipes.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
  group Middlewares/FatFS/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFS/src/: ff.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c ts_calibration.c menu.c usbh_conf.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Application/User/HID
    ../Src/: hid_menu.c mouse.c keyboard.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFS/Options
    ../../../../../../Middlewares/Third_Party/FatFS/src/option/: unicode.c syscall.c
target STM32F723E-DISCOVERY_USBH-HS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: as above
  output: STM32F723E-DISCOVERY_USBH-HS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,USE_USB_HS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 5.0.1
