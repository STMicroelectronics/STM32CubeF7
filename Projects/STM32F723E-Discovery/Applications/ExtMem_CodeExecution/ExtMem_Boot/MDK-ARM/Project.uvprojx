# Keil uVision project Project.uvprojx, settings and files
target STM32F723E_Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F730I8Kx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.2
  cpu: IROM(0x08000000-0x800FFFF) IRAM(0x20000000-0x2003FFFF) IRAM2(0x00000000-0x3FFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F730xx,USE_STM32F723E_DISCO
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F723E-Discovery;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Drivers/BSP/Components
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x0 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f730xx.s
  group Application/User
    ../Src/: fmc.c main.c memory_msp.c qspi.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash_ex.c
software components: CMSIS:CORE 4.3.0
