# Keil uVision project Project.uvprojx, settings and files
target STM32F723IE_Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,USE_USB_FS
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F723E-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_ioreq.c usbh_core.c usbh_pipes.c
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32f723xx.s
  group Middlewares/FatFs/Option
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Drivers/BSP/STM327F723IE_Discovery
    ../../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery.c stm32f723e_discovery_ts.c stm32f723e_discovery_lcd.c stm32f723e_discovery_psram.c stm32f723e_discovery_audio.c
  group Application/User
    ../Src/: waveplayer.c stm32f7xx_it.c explorer.c menu.c main.c ts_calibration.c usbh_conf.c waverecorder.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sai.c stm32f7xx_hal_i2s.c stm32f7xx_hal_gpio.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_hcd.c stm32f7xx_hal_rcc.c stm32f7xx_hal.c stm32f7xx_ll_fmc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
software components: CMSIS:CORE 4.3.0
