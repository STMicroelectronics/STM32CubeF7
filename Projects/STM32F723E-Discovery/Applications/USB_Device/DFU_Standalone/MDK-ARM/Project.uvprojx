# Keil uVision project Project.uvprojx, settings and files
target STM32F723IE-DISCOVERY_USBD-FS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F723IE-DISCOVERY_USBD-FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723IE_DISCO,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F723E-Discovery;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_sram.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Drivers/BSP/STM32F723IE_DISCOVERY
    ../../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery.c
  group Application/MDK-ARM
    ./: startup_stm32f723xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Application/User
    ../Src/: main.c usbd_dfu_flash.c usbd_desc.c usbd_conf.c stm32f7xx_it.c
target STM32F723IE-DISCOVERY_USBD-HS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.5
  cpu: as above
  output: STM32F723IE-DISCOVERY_USBD-HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723IE_DISCO,USE_USB_HS
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 4.3.0
