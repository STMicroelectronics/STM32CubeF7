<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>Project</project>
        <configuration>STM32F723IE-DISCOVERY_USBH-FS</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>STM32F723IE-DISCOVERY_USBH-HS</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>STM32F723IE-DISCOVERY_USBH-HS-IN-FS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


